# IAR project MH_DA_Led Blink.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C4 STM8S105C4
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S105
  ICCSTM8.CCIncludePath2: FWLib\Include; Main; User\Include; UserSTM8s\Include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: MH_DA_Led Blink.hex
  ILINK.IlinkOutputFile: MH_DA_Led Blink.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group FWLib
    FWLib/Source/: stm8s_clk.c stm8s_exti.c
  group Main
    Main/: main.c
  group User
    User/Source/: hieu_ung.c read_key.c
  group UserSTM8S
    UserSTM8s/Source/: user_delay.c user_gpio.c
